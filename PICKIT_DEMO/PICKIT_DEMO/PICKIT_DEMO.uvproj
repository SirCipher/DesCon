# Keil uVision project PICKIT_DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PICKIT_DEMO +hex
  c flags: Optim=2 wLevel=2
  c define: __FPU_PRESENT = 1, USE_STDPERIPH_DRIVER
  c include: .\Startup;.\Source;.\STM32F4-Discovery;.\STM32F4xx_StdPeriph_Driver\inc
  asm include: .\Source;.\Startup;.\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f4xx.s
    ./Startup/: system_stm32f4xx.c
  group Source
    ./Source/: I2C.c LCD.c SENSORS.c main.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c
    C:/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_can.c
    ./STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_can.h
  group STM32F4-Discovery
    ./STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_debug.c stm32f4_discovery_sdio_sd.c
